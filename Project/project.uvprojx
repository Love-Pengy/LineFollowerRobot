# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Src
    ../Src/: main.c SysClock.c startup_stm32l476xx.s delay.c sensor.c oled.c
    ../src/: motor.c
  group Include
    ../Include/: stm32l476xx.h SysClock.h globals.h delay.h sensor.h oled.h
    ../include/: motor.h
  group Lib
    ../Lib/OLED/: I2C.c I2C.h ssd1306.c ssd1306.h ssd1306_conf.h ssd1306_fonts.c ssd1306_fonts.h ssd1306_tests.c ssd1306_tests.h
software components: CMSIS:CORE 5.6.0
